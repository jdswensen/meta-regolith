EXTRA_OECONF += "-DPURIFY"
